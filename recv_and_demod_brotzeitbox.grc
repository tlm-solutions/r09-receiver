options:
  parameters:
    author: marenz
    generate_options: no_gui
    id: recv_and_demod
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: samp_rate//bw
  states: {}
- name: freq
  id: variable
  parameters:
    value: '170795000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/decimation/fsk_deviation_hz
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: update_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-45'
  states: {state: disabled}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: '-40'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '4096'
    port: '40000'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps/2
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '19500'
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)'
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=hackrf
    bb_gain0: '14'
    bw0: '1000000'
    freq0: freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '14'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: reveng_correlate_access_code_xx_ts_fl_0
  id: reveng_correlate_access_code_xx_ts_fl
  parameters:
    access_code: '00110011001101010101010101010100'
    len: '60'
    tagname: packet_len
    threshold: '2'
  states: {}
- name: reveng_correlate_access_code_xx_ts_fl_1
  id: reveng_correlate_access_code_xx_ts_fl
  parameters:
    access_code: '11001100110010101010101010101011'
    len: '60'
    tagname: packet_len
    threshold: '2'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0, '0']
- [analog_simple_squelch_cc_1, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_1, '0', qtgui_sink_x_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_socket_pdu_0, pdus]
- [digital_binary_slicer_fb_1, '0', reveng_correlate_access_code_xx_ts_fl_0, '0']
- [digital_binary_slicer_fb_1, '0', reveng_correlate_access_code_xx_ts_fl_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [reveng_correlate_access_code_xx_ts_fl_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [reveng_correlate_access_code_xx_ts_fl_1, '0', blocks_tagged_stream_to_pdu_1, '0']

metadata:
  file_format: 1
