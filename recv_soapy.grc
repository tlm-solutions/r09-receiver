options:
  parameters:
    generate_options: no_gui
    id: recv_and_demod
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: samp_rate//bw
  states: {}
- name: freq
  id: variable
  parameters:
    value: '170795000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '4'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '4096'
    port: '40000'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate/decimation/2400.
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '19500'
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)'
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '1'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: '0.5'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: remote=[2a00:8180:2c00:282:e65f:1ff:fe5d:1679]:55132,driver=remote,remote:driver=hackrf,soapy=0,remote:ipver=6
    bb_gain0: '30'
    bw0: '20000'
    freq0: freq
    gain0: '34'
    gain_mode0: 'False'
    if_gain0: '14'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: reveng_correlate_access_code_xx_ts_fl_1
  id: reveng_correlate_access_code_xx_ts_fl
  parameters:
    access_code: '1111110000000001'
    len: '20'
    tagname: packet_len
    threshold: '1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '4'
    samp_rate: samp_rate/decimation
    sym_rate: samp_rate/decimation/2400
    type: fir_filter_fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', high_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', high_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_socket_pdu_0, pdus]
- [digital_binary_slicer_fb_0, '0', reveng_correlate_access_code_xx_ts_fl_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [high_pass_filter_0, '0', hilbert_fc_0, '0']
- [high_pass_filter_0_0, '0', root_raised_cosine_filter_0, '0']
- [hilbert_fc_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [osmosdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [reveng_correlate_access_code_xx_ts_fl_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']

metadata:
  file_format: 1
